Commit message: fixed no legx and no legy

File: hopper_only.urdf (robot description, URDF)
Before this commit: robot 2D_Hopper, 3 links, 5 joints
Links:
- added link leg_x
- added link leg_y
